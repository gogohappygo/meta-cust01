IMAGE_INSTALL:append:raspberrypi4-64 = " kera-api-config"
